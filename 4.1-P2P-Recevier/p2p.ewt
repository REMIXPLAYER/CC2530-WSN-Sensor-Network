<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>8051</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <file>
    <name>$PROJ_DIR$\basic_rf.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\clock.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\hal_assert.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\hal_board.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\hal_int.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\hal_mcu.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\hal_rf.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\info.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\main.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\readme.txt</name>
  </file>
</project>


